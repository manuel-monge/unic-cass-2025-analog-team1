v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/home/designer/shared/designs/unic-cass-2025-analog-team1/unic-cass-analog/designs/libs/core_chiptop/user_project_wrapper/user_project_wrapper.sym} 920 -540 0 0 {name=x1}
