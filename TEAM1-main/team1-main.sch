v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {user_project_wrapper_team1.sym} 1280 -1060 0 0 {name=x1}
